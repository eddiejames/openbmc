KBRANCH ?= "dev-5.3"
LINUX_VERSION ?= "5.3.7"

SRCREV="ba827e449da17128953a9ff51fd558c69ae92f14"

require linux-aspeed.inc
